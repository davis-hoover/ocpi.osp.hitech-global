
SRC_URI_append = " \
        file://0001-Patch-to-add-short-delay-after-PL-init.patch \
        "

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

EXTERNALXSCTSRC = ""
EXTERNALXSCTSRC_BUILD = ""
